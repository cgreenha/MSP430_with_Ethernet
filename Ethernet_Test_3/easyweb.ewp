# IAR project easyweb.ewp, settings and files
configuration Debug (MSP430, debug)
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\CLIB\; $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk430F149.xcl
configuration Release (MSP430)
  as the first configuration, except:
  group (top)
    ./: cs8900.c easyweb.c support.s43 tcpip.c
